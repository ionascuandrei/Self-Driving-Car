SRC_URI_append = " file://platform-top.h"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://user_2019-01-19-14-16-00.cfg \
            file://user_2019-04-03-00-58-00.cfg \
            "

